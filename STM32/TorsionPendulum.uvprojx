# Keil uVision project TorsionPendulum.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TorsionPendulum +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\inc;.\src;.\STM32_USB-FS-Device_Driver
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: hw_config.c IRQHandlers.c main.c periphery_init.c stm32_it.c sysclock_init.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group inc
    ./inc/: hw_config.h main.h platform_config.h stm32_it.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h
  group STM32_USB_FS_Device_Driver
    ./STM32_USB-FS-Device_Driver/: usb_core.c usb_core.h usb_def.h usb_init.c usb_init.h usb_int.c usb_int.h usb_lib.h usb_mem.c usb_mem.h usb_regs.c usb_regs.h usb_sil.c usb_sil.h usb_type.h
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
